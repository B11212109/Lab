# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\Armcomplier506)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.2
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1,NDEBUG
  c include: ..\HAL\OLED_UI_Core;..\HAL\OLED_UI_Core\OLED_UI;..\HAL\OLED_UI_Core\Driver\Hardware_Driver;..\HAL\OLED_UI_Core\Driver\Software_Driver;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f403a_407_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c solve.c prun_table.c color_detect.c color_sensor_logic.c color_sensor_port.c cube_app.c bsp_stepper.c motor_ctrl_logic.c motor_ctrl_port_stub.c bsp_hmi.c ui_menu.c
    ../HAL/OLED_UI_Core/Driver/Hardware_Driver/: OLED_driver.c OLED_UI_Driver.c
    ../HAL/OLED_UI_Core/Driver/Software_Driver/: OLED.c OLED_Fonts.c
    ../HAL/OLED_UI_Core/OLED_UI/: OLED_UI.c OLED_UI_MenuData.c misc.c
    ../HAL/OLED_UI_Core/: OLED_UI_Launcher.c
  group headers
    ../inc/: bsp_stepper.h bsp_hmi.h color_detect.h color_sensor_api.h color_sensor_cfg.h color_sensor_port.h cube_app.h ui_menu.h solve.h
    ../HAL/OLED_UI_Core/Driver/Software_Driver/: OLED.h OLED_Fonts.h
    ../HAL/OLED_UI_Core/Driver/Hardware_Driver/: OLED_driver.h OLED_UI_Driver.h
    ../HAL/OLED_UI_Core/OLED_UI/: OLED_UI.h OLED_UI_MenuData.h misc.h
    ../HAL/OLED_UI_Core/: OLED_UI_Launcher.h
  group bsp
    ../../../at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group readme
    ../: readme.txt
